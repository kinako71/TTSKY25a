VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO (UNNAMED)
  CLASS BLOCK ;
  FOREIGN (UNNAMED) ;
  ORIGIN 0.000 0.000 ;
  SIZE 1.000 BY 1.000 ;
END (UNNAMED)
END LIBRARY

